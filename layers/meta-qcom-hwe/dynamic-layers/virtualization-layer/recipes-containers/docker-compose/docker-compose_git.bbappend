#Remove docker-plugin to install docker-compose at ${bindir} path
PACKAGECONFIG:remove = "docker-plugin"
