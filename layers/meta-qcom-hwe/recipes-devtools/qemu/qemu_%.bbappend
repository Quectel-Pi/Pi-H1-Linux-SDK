PACKAGECONFIG:append:qcom = " virtfs vhost gtk+ libusb"
