# Drop unbuildable patches
SRC_URI:remove:qcom = "file://bug344802-unhandled-0xec510f1e.patch"
