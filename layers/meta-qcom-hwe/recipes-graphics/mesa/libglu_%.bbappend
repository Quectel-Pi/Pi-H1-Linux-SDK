DEPENDS:append:qcom-custom-bsp = " qcom-adreno"
