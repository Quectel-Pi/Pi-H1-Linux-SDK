DEBUG_OPTIMIZATION:append = " -Wno-error=maybe-uninitialized"
