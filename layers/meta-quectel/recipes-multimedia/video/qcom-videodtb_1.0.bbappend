FILESPATH:prepend =  "${WORKSPACE}/sources/quectel-src:"
SRC_URI = "file://video-devicetree"
S = "${WORKDIR}/video-devicetree"

