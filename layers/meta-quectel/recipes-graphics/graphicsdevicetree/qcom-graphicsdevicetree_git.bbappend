FILESPATH:prepend =  "${WORKSPACE}/sources/quectel-src:"
SRC_URI = "file://graphics-devicetree"
S = "${WORKDIR}/graphics-devicetree"

