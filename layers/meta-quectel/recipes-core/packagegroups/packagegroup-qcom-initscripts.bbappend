RDEPENDS:${PN}:append = " initscripts-automount-ucard"
