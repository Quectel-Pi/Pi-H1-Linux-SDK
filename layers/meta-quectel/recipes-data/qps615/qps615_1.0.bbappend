FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-support-get-phy-interface-and-addrs-from-dts.patch;striplevel=4"
