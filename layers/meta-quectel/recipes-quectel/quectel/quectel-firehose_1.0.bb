DESCRIPTION = "Quectel QFirehose"
LICENSE = "CLOSED"

inherit cmake 

SRC_URI = "file://QFirehose.tgz"

S = "${WORKDIR}/QFirehose"
