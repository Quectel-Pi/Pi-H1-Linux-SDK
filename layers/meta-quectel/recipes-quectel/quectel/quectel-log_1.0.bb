DESCRIPTION = "Quectel QLog"
LICENSE = "CLOSED"

inherit cmake 

SRC_URI = "file://QLog.tgz"

S = "${WORKDIR}/QLog"
