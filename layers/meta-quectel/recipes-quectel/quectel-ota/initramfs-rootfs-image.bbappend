PACKAGE_INSTALL += " \
    initramfs-module-ota \
"