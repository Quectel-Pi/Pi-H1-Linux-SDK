FILESPATH:prepend =  "${WORKSPACE}/src/devicetree:"
SRC_URI = "file://wlan-devicetree"
S = "${WORKDIR}/wlan-devicetree"

