EXTRA_IMAGECMD:vfat = " -s 16 -S 4096"   